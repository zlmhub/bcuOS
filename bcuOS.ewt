<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Applicaton</name>
    <group>
      <name>Fatfs</name>
      <file>
        <name>$PROJ_DIR$\Code\Application\Fatfs\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\Application\Fatfs\ff.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\Application\Fatfs\ffsystem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\Application\Fatfs\ffunicode.c</name>
      </file>
    </group>
    <group>
      <name>Modbus</name>
      <group>
        <name>Functions</name>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfunccoils.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncdiag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncdisc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncholding.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncinput.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbfuncother.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\functions\mbutils.c</name>
        </file>
      </group>
      <group>
        <name>Port</name>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\port\portevent.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\port\portserial.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\port\porttimer.c</name>
        </file>
      </group>
      <group>
        <name>RTU</name>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\rtu\mbcrc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\Application\Modbus\rtu\mbrtu.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Code\Application\Modbus\mb.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\Code\Application\bcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Code\Application\bmu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Code\Application\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Code\Application\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Code\Application\modbus_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Code\Application\modbus_debug.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>LPC1758</name>
      <group>
        <name>Device</name>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\board.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\bxcan.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\fm24cxx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\mcp2515.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\pin.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\pwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\rs485.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\sd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Device\uart.c</name>
        </file>
      </group>
      <group>
        <name>Source</name>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\debug_frmwrk.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_clkpwr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_emac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_gpdma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_i2s.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_iap.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_libcfg_default.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_mcpwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_nvic.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_pinsel.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_pwm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_qei.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_rit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_ssp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_systick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Code\BSP\LPC1758\Source\lpc17xx_wdt.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Code\BSP\LPC1758\startup_LPC17xx.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\BSP\LPC1758\system_LPC17xx.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>uCOS-II</name>
    <group>
      <name>App</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\App\App.c</name>
      </file>
    </group>
    <group>
      <name>Config</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Config\os_cfg.h</name>
      </file>
    </group>
    <group>
      <name>Device</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Device\os_device.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Device\os_object.c</name>
      </file>
    </group>
    <group>
      <name>Ports</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Ports\os_cpu_a.S</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Ports\os_cpu_c.c</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_flag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_mbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_mutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_q.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_sem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Code\uCOS-II\Source\os_tmr.c</name>
      </file>
    </group>
  </group>
</project>


