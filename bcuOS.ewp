# IAR project bcuOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1758 NXP LPC1758
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: Code\uCOS-II\Config; Code\uCOS-II\Ports; Code\uCOS-II\Source; Code\uCOS-II\Device; Code\uCOS-II\App; Code\BSP\LPC1758\Include; Code\BSP\LPC1758; Code\BSP\LPC1758\Device; Code\Application\Modbus\include; Code\Application\Modbus\port; Code\Application\Modbus\rtu; Code\Application\Fatfs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BMS.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: Code\uCOS-II\Config; Code\uCOS-II\Ports; Code\uCOS-II\Source; Code\uCOS-II\Device; Code\uCOS-II\App; Code\BSP\LPC1758\Include; Code\BSP\LPC1758; Code\BSP\LPC1758\Device
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: BMS.hex
  group Applicaton
    Code/Application/: bcu.c bmu.c crc.c main.c modbus_app.c modbus_debug.c
  group Applicaton/Fatfs
    Code/Application/Fatfs/: diskio.c ff.c ffsystem.c ffunicode.c
  group Applicaton/Modbus
    Code/Application/Modbus/: mb.c
  group Applicaton/Modbus/Functions
    Code/Application/Modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Applicaton/Modbus/Port
    Code/Application/Modbus/port/: portevent.c portserial.c porttimer.c
  group Applicaton/Modbus/RTU
    Code/Application/Modbus/rtu/: mbcrc.c mbrtu.c
  group BSP/LPC1758
    Code/BSP/LPC1758/: startup_LPC17xx.s system_LPC17xx.c
  group BSP/LPC1758/Device
    Code/BSP/LPC1758/Device/: adc.c board.c bxcan.c fm24cxx.c gpio.c mcp2515.c pin.c pwm.c rs485.c rtc.c sd.c spi.c timer.c uart.c
  group BSP/LPC1758/Source
    Code/BSP/LPC1758/Source/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_iap.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group uCOS-II/App
    Code/uCOS-II/App/: App.c
  group uCOS-II/Config
    Code/uCOS-II/Config/: os_cfg.h
  group uCOS-II/Device
    Code/uCOS-II/Device/: os_device.c os_object.c
  group uCOS-II/Ports
    Code/uCOS-II/Ports/: os_cpu_a.S os_cpu_c.c
  group uCOS-II/Source
    Code/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
